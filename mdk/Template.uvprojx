# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1,USE_RTOS=1,DEV_MMC=1
  c misc: --diag_suppress=66
  c include: .\App;.\App\Fatfs;.\App\sdcard;.\RTE\Graphics
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\RTE\Device\LPC54608J512ET180_M4\LPC54608J512_flash.scf
  group app
    ./App/: main.c touch_task.c File_task.c
  group mcuconfig
    ./App/: LCDconf.c touch_I2C.c
  group GUI
    ./RTE/Graphics/: WindowDLG.c
  group touch panal
    ./App/: fsl_ft5406.c fsl_ft5406.h
  group sdcard
    ./App/sdcard/: fsl_mmc.c fsl_sd.c fsl_sdio.c fsl_sdmmc_common.c fsl_sdmmc_event.c fsl_sdmmc_host.c fsl_sdspi.c
  group Fatfs
    ./App/Fatfs/: diskio.c ff.c ffsystem.c ffunicode.c fsl_sd_disk.c
  group doc
    ./App/: readme.txt
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.0, Device:SDK Drivers:emc 2.0.0, Device:SDK Drivers:flexcomm 2.0.0, Device:SDK Drivers:gpio 2.1.1, Device:SDK Drivers:i2c 2.0.1, Device:SDK Drivers:inputmux 2.0.0, Device:SDK Drivers:inputmux_connections 2.0.0, Device:SDK Drivers:iocon 2.0.0, Device:SDK Drivers:lcdc 2.0.0, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:powerlib 2.0.0, Device:SDK Drivers:reset 2.0.0, Device:SDK Drivers:sctimer 2.0.0, Device:SDK Drivers:sdif 2.0.4, Device:SDK Drivers:usart 2.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:Startup 1.0.0, Graphics:CORE 5.42.9, Graphics:Display:Interface Template 5.42.9, Graphics:Tools:GUI Builder 5.42.9
